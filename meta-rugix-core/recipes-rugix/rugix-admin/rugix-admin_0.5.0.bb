PV = "0.5.0"
SRCREV = "3ee032294da00b38000d6f482e3ece18d51a2954"

require rugix-admin.inc
