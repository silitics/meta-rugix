PV = "0.5.0-rc.1+git"
SRCREV = "9c62c0120398b5e133035dd94f782f7ba311cd95"

require rugix-admin.inc
