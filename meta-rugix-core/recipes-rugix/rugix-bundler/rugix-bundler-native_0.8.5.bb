RUGIX_VERSION = "0.8.5"
SRC_URI[x86_64.sha256sum] = "9acc029066c32851f64816033d035c6e2eb2e34de1035e063f19930b26a8da8f"
SRC_URI[aarch64.sha256sum] = "ab4523ead534b6fedb388f22930eadabff1285d49f070c74338ee1ecb0c7262c"

require rugix-bundler-native.inc
