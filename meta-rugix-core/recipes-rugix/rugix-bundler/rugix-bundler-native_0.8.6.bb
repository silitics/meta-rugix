RUGIX_VERSION = "0.8.6-dev.1"
SRC_URI[x86_64.sha256sum] = "3d0a2ef0553c14a149797440e0244671364d2519ff96069fd5aa5d45fa54f52d"
SRC_URI[aarch64.sha256sum] = "de9750dee0b10557f6c7f49e059ccede830d55dfa4d249a7cadf2afae5f2b092"

require rugix-bundler-native.inc
