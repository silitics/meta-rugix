SRCREV = "48fc40d3d903730781f3dc4bf671873d2308573a"

require rugix-bundler-native.inc
