RUGIX_VERSION = "0.8.6-dev.0"
SRC_URI[x86_64.sha256sum] = "23211ea08021caad3a8572af870ade4b558f54b249303cfa125c7cafd01ee1c2"
SRC_URI[aarch64.sha256sum] = "7ce8399e3bc790a93c2316a3d5880fee83732acf37b3a5656078200ddc1edbb3"

require rugix-ctrl-bin.inc