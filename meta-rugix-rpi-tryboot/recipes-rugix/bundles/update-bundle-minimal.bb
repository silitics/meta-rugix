inherit rugix-bundle
